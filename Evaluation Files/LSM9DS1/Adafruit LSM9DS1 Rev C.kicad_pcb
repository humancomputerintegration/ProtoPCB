# Repository humancomputerintegration/ProtoPCB

File README.md:

# ProtoPCB

This repository contains our tests, evaluation files, and software tool (ProtoPCB) presented in the paper "ProtoPCB: Reclaiming Printed Circuit Board E-waste as Prototyping Material", which will appear at CHI2025. This tool was built by Jasmine Lu (@xjasminelu), Sai Rishitha Boddu (@rishiboddu) with project assistance from Pedro Lopes at the University of Chicago's [Human Computer Integration Lab](https://lab.plopes.org).

## ProtoPCB Software 
ProtoPCB is a python-based tool that builds off of [KiCad](https://www.kicad.org/) command line tools, [Tkinter](https://docs.python.org/3/library/tkinter.html), [OpenCV](https://opencv.org/), [CairoSVG](https://cairosvg.org/), and [pcb-tools](https://github.com/curtacircuitos/pcb-tools). It is designed to support analyzing PCB Boards to identify ways they can be reused to implement new circuits. It does so by taking an input schematic and using computer vision to scan boards for their solder pads, conducting traces, and vias in order to map out the relevant connections of the board. Using this mapping, it analyzes all the methods that can be used to implement a circuit (positions to place a component, wires to add, traces to cut, etc.).

### Features Overview

*PCB Board representation*

*Component representation*

*Net representation*

*Circuit representation*

*Component matching*

*Net matching*

*Circuit matching*

*GUI*

*Camera Image to ProtoPCB Input*

*Test Suite*

## Repository Organization
### Code
Code is organized in the code directory. This includes ProtoPCB's base code (scripts, GUI, test suite). You can use this to run technical evaluations (via scripts in tests.py).

### Evaluation Files
All files and data for the Technical Evaluation (PCB boards) can be found in the [Evaluation Files](./Evaluation Files) directory

### Installation
To use ProtoPCB, you must have installed KiCad and Python3 on your machine. The system was built primarily with Mac OS. It has not been tested yet on Windows so some elements may not port over well. If you're interested in collaborating on a Windows version, please reach out!

Detailed instructions can be found on the page [INSTALL.md](./INSTALL.md)

## Contributing
### Submitting issues
As this tool was born out of a research project, it is a _prototype_. However, we'd love to hear about any bugs you might encounter during use of our tool. We encourage you to submit any issues that arise and we'll do our best to get around to them. Please note that there is only one (very busy) PhD student who will be able to provide support, so please extend us grace with any issues you encounter!

### How to contribute
(adapted from [Clipy](https://github.com/Clipy/Clipy))
1. Fork it ( https://github.com/humancomputerintegration/ProtoPCB/fork )
2. Create your feature branch (`git checkout -b my-new-feature`)
3. Commit your changes (`git commit -am 'Add some feature'`)
4. Push to the branch (`git push origin my-new-feature`)
5. Create a new Pull Request

### License & Citation
ProtoPCB is released under the [GNU GPL V3](./Software_License.txt). We would love to have you build off our work! Please reach out if we can be helpful in that.

When using or building upon this work in an academic publication, please consider citing as follows:

Jasmine Lu, Sai Rishitha Boddu, and Pedro Lopes. 2025. ProtoPCB: Reclaiming Printed Circuit Board E-waste as Prototyping Material. In Proceedings of the CHI Conference on Human Factors in Computing Systems 2025 (CHI’2025). Association for Computing Machinery, New York, NY, USA. https://doi.org/10.1145/3586183.3606745

### Contact
For questions or if something is wrong with this repository, contact jasminelu@uchicago.edu

## KiCad design Evaluation Files/LSM9DS1/Adafruit LSM9DS1 Rev C.kicad_pcb

Board: 2 copper layers, 29.0 x 21.0 mm, 29 parts (4 on the bottom side), 22 nets.

Parts:
C1: 0.1uF; 0603-NO
C2: 10uF; _0805MP
C3: 10uF; 0805-NO
C4: 0.22uF; 0603-NO
C5: 0.01uF; 0603-NO
CONN3, CONN4: STEMMA_I2C_QT; JST_SH4
D1: GREEN; CHIPLED_0603_NOOUTLINE
D2, D3, D4: 1N4148; SOD-323
FID3, FID4: FIDUCIAL_1MM
IC1: LSM9DS1; LGA24_3.5X3.1MM
JP2: 1X05_ROUND_70
JP4: PowerIO; 1X09_ROUND_70
Q2: BSS138; SOT363
R1, R5: 10K; 0603-NO
R2: 10k; RESPACK_4X0603
R3: 10K; RESPACK_4X0603
U2: AP2112K-3.3; SOT23-5
U$1, U$17: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$10, U$16: ADAFRUIT_2.5MM
U$25: PCBFEAT-REV-040
U$30, U$31: STEMMAQT

Connections:
3.3V: C1.1, C3.1, IC1.1, IC1.3, IC1.22, IC1.23, JP4.8, Q2.2, Q2.5, R1.1, R2.5, R2.6, R2.7, R2.8, R3.2, R3.4, R5.2, U2.5
C1: C4.1, IC1.24
CAP: C5.1, IC1.21
CS_A/G: D3.A, IC1.7, R2.2
CS_AG_5V: D3.C, JP4.4
CS_M: D2.A, IC1.8, R2.1
CS_M_5V: D2.C, JP4.3
DEN_3V: D4.A, IC1.13, R5.1
DEN_5V: D4.C, JP2.1
DRDY_M: IC1.9, JP2.5
GND: C1.2, C2.2, C3.2, C4.2, C5.2, CONN3.1, CONN3.MT1, CONN3.MT2, CONN4.1, CONN4.MT1, CONN4.MT2, D1.C, IC1.14, IC1.15, IC1.16, IC1.17, IC1.18, IC1.19, IC1.20, JP4.7, U2.2
INT1_AG: IC1.11, JP2.3
INT2_AG: IC1.12, JP2.2
INT_M: IC1.10, JP2.4
unnamed: D1.A, R1.2
SCL: CONN3.4, CONN4.4, JP4.6, Q2.6, R3.8
SCL_3V: IC1.2, Q2.1, R3.7
SDA: CONN3.3, CONN4.3, JP4.5, Q2.3, R3.6
SDA_3V: IC1.4, Q2.4, R3.5
SDO_AG: IC1.5, JP4.2, R2.4
SDO_M: IC1.6, JP4.1, R2.3
VCC: C2.1, CONN3.2, CONN4.2, JP4.9, R3.1, R3.3, U2.1, U2.3

## KiCad design Evaluation Files/Adafruit LM4040/Adafruit LM4040.kicad_pcb

Board: 2 copper layers, 16.0 x 19.0 mm, 10 parts (1 on the bottom side), 4 nets.

Parts:
D1: LM4040AIM3-2.0/NOPB; SOT23-R
D2: LM4040AIM3-4.1/NOPB; SOT23-R
FID1, FID2: FIDUCIAL""; FIDUCIAL_1MM
JP1: 1X04_ROUND
R1, R2: 750; 0805-NO
R3, R4: 10K; 0805-NO
U$5: ADAFRUIT_5MM

Connections:
2.048V: D1.1, JP1.3, R1.1, R3.1
4.096V: D2.1, JP1.4, R2.1, R4.1
GND: D1.2, D2.2, JP1.2, R3.2, R4.2
VIN: JP1.1, R1.2, R2.2

## KiCad design Evaluation Files/Circuit Playground/Adafruit Circuit Playground.kicad_pcb

Board: 16 copper layers, 61.0 x 60.0 mm, 81 parts (6 on the bottom side), 53 nets.

Parts:
BATT0: 3-6VDC; JSTPH2
C1: 0.1uF; 0603-NO
C2, C3, C5, C6, C7, C9: 1uF; 0603-NO
C4, C8: 10uF; 0805-NO
CN1: MicroB USB; 4UCONN_20329_V2
D1, D2: SCHOTTKY (1A); SOD-123
D4: 1N4148; SOD-323
D6: SEWTAP-ALLIGATOR; SEWALLI
GND3TAP0: SEWTAP-ALLIGATOR; SEWALLI
GNDTAP0, GNDTAP2: SEWTAP-ALLIGATOR; SEWALLI
IC1: ATMEGA32U4-MU; TQFN44_7MM
IC2: LMV358MM; MSOP08
IC4: LIS3DH; LGA16_3X3MM
IO9, IO10, IO12: SEWTAP-ALLIGATOR; SEWALLI
L0: RED; CHIPLED_0805_NOOUTLINE
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10: WS2812B3535; LED3535
PWR0: GREEN; CHIPLED_0805_NOOUTLINE
Q1: MMBT2222; SOT23-WIDE
R1, R2: 22; 0603-NO
R3, R5, R8: 1K; 0603-NO
R4, R6, R7, R10, R13, R14: 10K; 0603-NO
R9: 100K; 0603-NO
R11: 20K; 0603-NO
R15, R22: 1M; RESPACK_4X0603_NO
R21: 100; 0603-NO
RESET0: KMR2; BTN_KMR2_4.6X2.8
RX0: SEWTAP-ALLIGATOR; SEWALLI
SCL0: SEWTAP-ALLIGATOR; SEWALLI
SDA0: SEWTAP-ALLIGATOR; SEWALLI
SP1: 8MM; BUZZER_SMT_5MM
SW1, SW2: EVQQ; EVQ-Q2_SMALLER
SWITCH0: EG1390
THM1: 10K; _0402
TP1: MISO; TESTPOINT_ROUND_1.5MM
TP2: SCK; TESTPOINT_ROUND_1.5MM
TP3: RST; TESTPOINT_ROUND_1.5MM
TP4: MOSI; TESTPOINT_ROUND_1.5MM
TX0: SEWTAP-ALLIGATOR; SEWALLI
U1: SPW2430; SPW2430HR5H-B
U2: ALS-PT19-315C
U3: AP2112K-3.3; SOT23-5
U$1: SYMBOL_MINUS
U$2, U$3, U$6: FIDUCIAL""; FIDUCIAL_1MM
U$4: FLORAMED
U$7: PCBFEAT-REV-040
U$35: SYMBOL_PLUS
UNK3.3VTAP0, UNK3V3TAP2: SEWTAP-ALLIGATOR; SEWALLI
VCC2: SEWTAP-ALLIGATOR; SEWALLI
Y1: 8MHz; RESONATOR-SMD

Connections:
3.3V: C2.1, C3.1, C6.1, C7.1, C8.1, D4.C, IC1.6, IC1.14, IC1.24, IC1.34, IC1.44, IC2.8, IC4.1, IC4.13, IC4.14, IC4.15, IC4.16, LED1.2, LED2.2, LED3.2, LED4.2, LED5.2, LED6.2, LED7.2, LED8.2, LED9.2, LED10.2, R3.2, R6.1, R11.1, SP1.-, SW1.B, SW1.B', SW2.B, SW2.B', SWITCH0.O1, SWITCH0.O2, THM1.2, U1.4, U2.C, U3.5, UNK3.3VTAP0.P$1, UNK3V3TAP2.P$1
+5V: CN1.VBUS, D1.A, IC1.7
A0_TEMP_SENSE: IC1.36, R7.2, THM1.1
A1_RIGHTBUTTON: IC1.37, R13.2, SW2.A, SW2.A'
A3_SWITCH: IC1.39, SWITCH0.P1
A4_SOUND_SENSE: IC1.40, IC2.1, R9.1
A5_LIGHT_SENSE: IC1.41, R4.2, U2.E
D0/RX: IC1.20, R15.6, RX0.P$1
D1/TX: IC1.21, R15.5, TX0.P$1
D2_SDA: IC1.19, R15.7, SDA0.P$1
D3_SCL: IC1.18, R15.8, SCL0.P$1
D6: D6.P$1, IC1.27, R22.7
D7_LISINT: IC1.1, IC4.11
D8: IC1.28, IC4.8, R6.2
D9: IC1.29, IO9.P$1, R22.8
D10: IC1.30, IO10.P$1, R22.5
D12: IC1.26, IO12.P$1, R22.6
D13: IC1.32, R5.1
D+: CN1.D+, R2.1
D-: CN1.D-, R1.1
GND: BATT0.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, CN1.BASE@1, CN1.BASE@2, CN1.GND, CN1.SPRT@1, CN1.SPRT@2, CN1.SPRT@3, CN1.SPRT@4, GND3TAP0.P$1, GNDTAP0.P$1, GNDTAP2.P$1, IC1.5, IC1.15, IC1.23, IC1.33, IC1.35, IC1.43, IC2.4, IC4.5, IC4.10, IC4.12, L0.C, LED1.4, LED2.4, LED3.4, LED4.4, LED5.4, LED6.4, LED7.4, LED8.4, LED9.4, LED10.4, PWR0.C, Q1.2, R4.1, R7.1, R10.2, R13.1, R14.1, RESET0.B, RESET0.B', SWITCH0.S1, SWITCH0.S2, U1.2, U1.3, U3.2, Y1.2
LEFTBUTTON: IC1.25, R14.2, SW1.A, SW1.A'
MISO: IC1.11, IC4.7, TP1.P$1
MOSI: IC1.10, IC4.6, TP4.P$1
unnamed: PWR0.A, R3.1
unnamed: IC2.2, R8.2, R9.2
unnamed: IC1.3, R1.2
unnamed: IC1.4, R2.2
unnamed: C9.1, IC2.5, R10.1, R11.2
unnamed: BATT0.2, D2.A
unnamed: IC1.17, Y1.1
unnamed: IC1.16, Y1.3
unnamed: L0.A, R5.2
unnamed: LED1.1, LED2.3
unnamed: LED1.3, LED3.1
unnamed: LED2.1, LED10.3
unnamed: LED6.3, LED7.1
unnamed: C1.2, R8.1
unnamed: LED7.3, LED8.1
unnamed: LED8.3, LED9.1
unnamed: LED9.3, LED10.1
unnamed: LED3.3, LED4.1
unnamed: LED4.3, LED5.1
unnamed: D4.A, Q1.3, SP1.+
unnamed: Q1.1, R21.1
NEOPIX: IC1.8, LED6.1
RST: IC1.13, RESET0.A, RESET0.A', TP3.P$1
SCK: IC1.9, IC4.4, TP2.P$1
SOUNDOUT: C1.1, U1.1
SPEAKER: IC1.31, R21.2
TXLED: IC1.22, R15.1, R15.2, R15.3, R15.4, R22.1, R22.2, R22.3, R22.4
VCC: C4.1, C5.1, D1.C, D2.C, U3.1, U3.3, VCC2.P$1
VCC/2: IC2.3, IC2.6, IC2.7

## KiCad design Evaluation Files/ACS72x-Breakout_v11/ACS72x-Breakout_v11.kicad_pcb

Board: 2 copper layers, 26.0 x 26.0 mm, 15 parts (1 on the bottom side), 6 nets.

Parts:
@HOLE0, @HOLE1: (no value)
C1: 100n; C0402
C2A0: 1n; C0402
C2B0: nb; C0603
IC1: ACS724LLCTR; SO8
J1: MA03-1
LOGO1: LOGO_CE-2; CE_2MM
LOGO2: OSHW_LOGOX0070; OSHW_6X70
LOGO3: LOGO-S_PLACE_S; SPARK_TPLACE_S
LOGO4: LOGO_WEEE-4; WEEE_4MM
PAD1, PAD2: 5-2,5
X1, X2: PASSER-07; PASSER_07MM

Connections:
FLT: C2A0.2, C2B0.2, IC1.6
GND: C1.1, C2A0.1, C2B0.1, IC1.5, J1.1
IP+: IC1.1, IC1.2, PAD1.1
IP-: IC1.3, IC1.4, PAD2.1
VCC: C1.2, IC1.8, J1.2
VIOUT: IC1.7, J1.3

## KiCad design Evaluation Files/Stepper-driver/Stepper_driver_DRV8825.kicad_pcb

Parts:
C1: 12101C335K4T2A; 1210C
C2, C3, C4: CL21B104KCFNNNE; 0805C
C5: 08051C103KAT2A; 0805C
C6: 470n; 0603C
D1: purple; 0402LED
FD1: FIDUCIAL; FIDUCIAL_23
H1, H2, H3, H4: HOLE_3.2mm
JP1: SMD-JUMPER-CONNECTED_TRACE_SLODERMASK
K1, K2: HEADER_MALE_8X1
R1, R3: 73L2R20G; 0603R
R2: 1M; 0603R
R4: tc33x-2-104e; tc33x-2-103e
R5: 1k5; 0603R
R6, R8: 10k; 0603R
R7: 2k2; 0402R
U1: DRV8825

Connections:
3V3: C6.2, R4.1, U1.15 (V3P3OUT)
A1: K2.4, U1.5 (AOUT1)
A2: K2.3, U1.7 (AOUT2)
B1: K2.5, U1.10 (BOUT1)
B2: K2.6, U1.8 (BOUT2)
DECAY: U1.19 (DECAY)
DIR: K1.1, U1.20 (DIR)
GND: C1.1, C2.1, C3.1, C6.1, D1.2 (K), K2.1, K2.7, R1.1, R3.1, R4.3, U1.14 (GND), U1.28 (GND), U1.29 (TP)
MODE0: K1.7, U1.24 (MODE0)
MODE1: K1.6, U1.25 (MODE1)
MODE2: K1.5, U1.26 (MODE2)
unnamed: C4.2, R2.2, U1.3 (VCP)
unnamed: C5.1, U1.2 (CP2)
unnamed: C5.2, U1.1 (CP1)
unnamed: D1.1 (A), R7.2
unnamed: JP1.2, R7.1
unnamed: R1.2, U1.6 (ISENA)
unnamed: R3.2, U1.9 (ISENB)
unnamed: R4.2, U1.12 (AVREF), U1.13 (BVREF)
unnamed: R5.2, U1.18 (nFAULT)
STEP: K1.2, U1.22 (STEP)
VMM: C1.2, C2.2, C3.2, C4.1, JP1.1, K2.8, R2.1, U1.4 (VMA), U1.11 (VMB)
~EN: K1.8, U1.21 (nENBL)
~FAULT: K2.2, R5.1, R6.2, R8.2
~RESET: K1.4, R8.1, U1.16 (nRESET)
~SLEEP: K1.3, R6.1, U1.17 (nSLEEP)

Notes on the sheet:
HEADER
DRV8825 STEPPER DRIVER
PWR LED

Board: 2 copper layers, 48.5 x 33.0 mm, 24 parts (2 on the bottom side), 25 nets.

## KiCad design Evaluation Files/Cantact/cantactpro.kicad_pcb

Board: 2 copper layers, 112.5 x 85.5 mm, 99 parts (0 on the bottom side), 54 nets.

Parts:
C1, C2, C33: 4.7u; C_0805
C3, C34: 10u; C_0805
C4, C7, C8, C9, C11, C14, C16, C18, C20, C22, C24, C26, C28, C32: 0.1u; C_0603
C5, C6: 470 pF/5 kV; C_1812
C10, C12: 100p; C_0603
C13, C15, C17, C19, C21, C23, C25, C27, C29: 0.01u; C_0603
C30, C31: 33p; C_0603
D1, D3: LED_GRN; LED_0603
D2, D4: LED_RED; LED_0603
D5: ESD9X5; SOD-923
D6: D; D_SMA
H1, H2, H3, H4: MOUNT_HOLE; MountingHole_3.2mm_M3
J1: USB_B
J2, J3: DB9; LD09P
J4: SWD; Pin_Header_Straight_2x05_Pitch1.27mm
JP1: Boot Switch; TE_1825027-5
L1: 4.7u; L_0805
L2: 47u; L_1206
LP1, LP2, LP3, LP4: Light Pipe; SLP3-150-zzz-x
R1, R2, R3, R4, R5, R6, R7: 100; R_0603
R8, R14, R15: 10k; R_0603
R9, R10: 2.7k; R_0603
R11: 1k; R_0603
R12: 0; R_0603
R13: 12.4k; R_0603
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16: TEST; Measurement_Point_Round-TH_Small
U1: TPD2E2U06; SOT-553
U2: AP2114H-3.3; SOT-223
U3: ROE-0505S
U4: Si864x; SOIC-16_3.9x9.9mm_Pitch1.27mm
U5: LTV-846; SMD-16
U6, U11: 74LVC1G3157; SOT-363_SC-70-6
U7: NCV7356D1; SOIC-8_3.9x4.9mm_Pitch1.27mm
U8: MCP25612FD; SOIC-14_3.9x8.7mm_Pitch1.27mm
U9, U10: NUP2125; SC-70
U12: LPC54616J512BD100; LQFP-100_14x14mm_Pitch0.5mm
Y1: 12 MHz; CSM-3X

Connections:
+3V3: C2.1, C4.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C32.1, C33.1, C34.1, J4.1, R14.2, R15.2, TP3.1, U2.2, U2.4, U4.1, U4.7, U5.3, U5.5, U5.7, U12.1, U12.10, U12.11, U12.21, U12.31, U12.32, U12.33, U12.45, U12.50, U12.54, U12.75, U12.76, U12.99
+5VD: C5.1, C7.2, C8.1, C9.1, R9.1, TP9.1, U3.4, U4.10, U4.16, U5.10, U5.12, U5.14, U6.5, U8.3, U8.7, U11.5
+12V: C10.1, C11.2, D6.1, U7.5
/12V_DB9: D6.2, J2.9
/CAN0_MODE: R8.2, TP14.1, U5.9, U6.6, U11.6
/CAN0_RX: TP12.1, U4.12, U11.4
/CAN0_RX_HS: U8.4, U11.3
/CAN0_RX_SW: R9.2, U7.4, U11.1
/CAN0_TX: TP10.1, U4.14, U6.4
/CAN0_TX_HS: U6.3, U8.1
/CAN0_TX_SW: U6.1, U7.1
/CAN1_RX: TP13.1, U4.11, U8.8
/CAN1_TX: TP11.1, U4.13, U8.5
/CANH0: J2.7, U8.13, U10.1
/CANH1: J3.7, U8.10, U9.1
/CANH_SW: C12.2, D5.1, J2.4, L2.2, R11.1
/CANL0: J2.2, U8.12, U10.2
/CANL1: J3.2, U8.9, U9.2
/MCU/BOOTMODE: JP1.1, R12.2, U12.90
/MCU/CAN0_RX: TP6.1, U4.5, U12.60
/MCU/CAN0_TX: TP4.1, U4.3, U12.58
/MCU/CAN1_RX: TP7.1, U4.6, U12.5
/MCU/CAN1_TX: TP5.1, U4.4, U12.47
/MCU/ISP1: R12.1, U12.89
/MCU/LED_1: D1.2, U12.35
/MCU/LED_2: D2.2, U12.36
/MCU/LED_3: D3.2, U12.37
/MCU/LED_4: D4.2, U12.38
/MCU/RESETN: J4.10, U12.48
/MCU/SWCAN_ENABLE: R7.1, U12.77
/MCU/SWCAN_MODE0: R5.1, U12.83
/MCU/SWCAN_MODE1: R6.1, U12.78
/MCU/SWCLK: J4.4, R15.1, U12.24
/MCU/SWDIO: J4.2, R14.1, U12.25
/MCU/USB+: J1.3, U1.5, U12.13
/MCU/USB-: J1.2, U1.3, U12.12
/SW_MODE0: TP15.1, U5.13, U7.2
/SW_MODE1: TP16.1, U5.11, U7.3
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.1, C31.1, C32.2, C33.2, C34.2, J1.4, J1.5, J4.3, J4.5, J4.9, JP1.2, R1.1, R2.1, R3.1, R4.1, R13.1, TP2.1, U1.4, U2.1, U3.1, U4.2, U4.8, U12.2, U12.6, U12.14, U12.22, U12.30, U12.34, U12.49, U12.51, U12.53, U12.71, U12.79, U12.96
GNDD: C6.1, C7.1, C8.2, C9.2, C10.2, C11.1, C12.1, D5.2, J2.3, J2.6, J3.3, J3.6, R8.1, TP8.1, U3.3, U4.9, U4.15, U6.2, U7.8, U8.2, U8.6, U8.11, U8.14, U9.3, U10.3, U11.2
unnamed: C5.2, L1.2, U3.2
unnamed: C30.2, U12.20, Y1.2
unnamed: C31.2, U12.19, Y1.1
unnamed: D1.1, R1.2
unnamed: D2.1, R2.2
unnamed: D3.1, R3.2
unnamed: D4.1, R4.2
unnamed: L2.1, R10.1, R11.2, U7.7
unnamed: R5.2, U5.4
unnamed: R6.2, U5.6
unnamed: R7.2, U5.8
unnamed: R10.2, U7.6
unnamed: R13.2, U12.7
VBUS: C1.1, C3.1, J1.1, L1.1, TP1.1, U2.3, U12.9

## KiCad design Evaluation Files/VEML6070/Adafruit VEML6070.kicad_pcb

Board: 2 copper layers, 17.0 x 16.5 mm, 12 parts (2 on the bottom side), 6 nets.

Parts:
C1: 10uF; 0805-NO
FID1: FIDUCIAL""; FIDUCIAL_1MM
JP1: 1X05_ROUND_70
R1, R2, R4: 10K; 0805-NO
R3: 270K; 0805-NO
U1: VEML6070
U$2: PCBFEAT-REV-040
U$10, U$11: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$14: ADAFRUIT_2.5MM

Connections:
ACK: JP1.5, R4.1, U1.2
GND: C1.2, JP1.2, R3.1, U1.1
SCL: JP1.3, R1.1, U1.5
SDA: JP1.4, R2.1, U1.3
SET: R3.2, U1.4
VDD: C1.1, JP1.1, R1.2, R2.2, R4.2, U1.6

## KiCad design Evaluation Files/BioAmp-EXG-Pill/BioAmp-EXG-Pill.kicad_pcb

Parts:
C1: 47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C4: 1nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C7: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: BPFC_C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1: BioAmp Output; PinHeader_1x03_P2.54mm_Vertical
J2: BioAmp Input; PinHeader_1x03_P2.54mm_Vertical
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R10: 220K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R8, R9, R13, R14: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R7: 22K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: RG; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: BPFC_R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: Amp; TSSOP-14_4.4x5mm_P0.65mm
U2: LOGO_UDLABS; EXG

Connections:
DRL: J2.1, JP2.2 (C), R11.1; also elsewhere on the board
GND: C3.2, C6.1, C7.1, J1.2, R9.1, U1.11 (V-); also elsewhere on the board
IN+: C4.1, J2.2, R14.1, U1.5 (+); also elsewhere on the board
IN-: C4.2, J2.3, R13.2, U1.3 (+); also elsewhere on the board
unnamed: C1.2, R1.1
unnamed: C3.1, R8.1, R9.2, U1.12 (+)
unnamed: JP1.1 (A), R4.1
unnamed: JP2.1 (A), R13.1
unnamed: JP2.3 (B), R14.2
unnamed: R2.1, R5.2, R6.2, U1.2 (-)
unnamed: R5.1, R7.2, U1.1
unnamed: R6.1, R7.1, R10.2, U1.6 (-)
VCC: C6.2, C7.2, J1.3, R8.2, U1.4 (V+); also elsewhere on the board
ampRef: R2.2, R11.2, U1.10 (+), U1.13 (-), U1.14
bpfIN: C1.1, C2.2, C5.2, R3.2, R4.2, R12.2, U1.9 (-)
bpfOUT: C2.1, C5.1, J1.1, JP1.2 (B), R3.1, R12.1, U1.8; also elsewhere on the board
inaOUT: R1.2, R10.1, U1.7

Notes on the sheet:
contact@upsidedownlabs.tech
1000x Gain Bandpass Filter
Create solder joint on JP1 to increase the Band Pass freqnecny range Default: Narrow input frequency band, use when recording EEG, EOG Configured: Wide input frequency band, use for ECG, EMG, and EOG
Band Pass Filter Configuration (BPFC)
Electrode config
C5 (BPFC_C) & R12 (BPFC_R) on the back side of the PCB can be used to configure the bandpass filter. Use them to configure output Gain (decrease) & Band (frequency range).
Header pins / Connectors
11x Gain Instrumentation Amp (INA)
Bridge all three pads of the solder jumper (JP2) to configure for 2 Electrode operations instead of the 3 electrodes Note: 2 electrodes will give noisier output than 3 electrodes!
Power supply filtering
Amp Ref + Driven Right Leg (DRL)
Removes high freqency noise.
Wide Band
INA gain config (only increase)
Electrode reference
INA Input filter

Board: 2 copper layers, 31.0 x 13.0 mm, 30 parts (6 on the bottom side), 17 nets.

Other parts of the board:
J1#2: BioAmp Output; PinHeader_1x03_P2.54mm_Vertical
J2#2, J2#3: BioAmp Input; PinHeader_1x03_P2.54mm_Vertical

Their connections:
DRL: J2#2.1, J2#3.1; also elsewhere on the board
GND: J1#2.2; also elsewhere on the board
IN+: J2#2.2, J2#3.2; also elsewhere on the board
IN-: J2#2.3, J2#3.3; also elsewhere on the board
VCC: J1#2.3; also elsewhere on the board
bpfOUT: J1#2.1; also elsewhere on the board

## Commit log

2024-12-11 codebase and evaluation files
2024-12-11 code base
2024-12-11 anonymized test script
2025-02-10 updated readme, still some elements incomplete
2025-02-11 ProtoPCB Install Guide
